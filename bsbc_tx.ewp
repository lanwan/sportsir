# IAR project bsbc_tx.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: D:\antplus_bsbc_tx\sensor\bsbc; D:\antplus_bsbc_tx\base; D:\antplus_bsbc_tx\sensor
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430g2553.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: D:\antplus_bsbc_tx\base; D:\antplus_bsbc_tx\sensor\bsbc
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group base
    base/: antdefines.h ANTInterface.c ANTInterface.h antmessage.h antplus.h common_pages.h Config.h ioboard.c ioboard.h printf.c printf.h serial.c serial.h System.c System.h timer.c timer.h types.h version.h
  group sensor/bsbc
    sensor/bsbc/: bc_tx.c bc_tx.h bs_tx.c bs_tx.h main_bsc_tx.c
